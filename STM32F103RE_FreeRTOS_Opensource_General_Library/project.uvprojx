# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\start;.\libraries;.\common;.\device;.\driver;.\user;.\tools;.\code;.\freertos;.\freertos\portable\RVDS\ARM_CM3;.\freertos\portable\MemMang;.\freertos\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ./start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group libraries
    ./libraries/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group common
    ./common/: common_headfile.h common_typedef.h common_clock.c common_clock.h common_debug.c common_debug.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_fifo.c zf_common_fifo.h common_cjson.c common_cjson.h common_mqttkit.c common_mqttkit.h
  group driver
    ./driver/: driver_adc.c driver_adc.h driver_delay.c driver_delay.h driver_dma.c driver_dma.h driver_encoder.c driver_encoder.h driver_exti.c driver_exti.h driver_flash.c driver_flash.h driver_gpio.c driver_gpio.h driver_pit.c driver_pit.h driver_pwm.c driver_pwm.h driver_pwmi.c driver_pwmi.h driver_soft_iic.c driver_soft_iic.h driver_soft_spi.c driver_soft_spi.h driver_iic.c driver_iic.h driver_spi.c driver_spi.h driver_uart.c driver_uart.h driver_can.c driver_can.h
  group device
    ./device/: zf_device_oled.c zf_device_oled.h zf_device_tft180.c zf_device_tft180.h zf_device_ips200.c zf_device_ips200.h zf_device_mpu6050.c zf_device_mpu6050.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_gnss.c zf_device_gnss.h zf_device_wireless_uart.c zf_device_wireless_uart.h zf_device_type.c zf_device_type.h zf_device_wifi_spi.c zf_device_wifi_spi.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_bluetooth_ch9141.c zf_device_bluetooth_ch9141.h device_nrf24l01.c device_nrf24l01.h device_tb6612.c device_tb6612.h device_w25q64.c device_w25q64.h device_dht11.c device_dht11.h device_esp8266.c device_esp8266.h device_key.c device_key.h device_mlx90614.c device_mlx90614.h device_tts.c device_tts.h
  group code
    ./code/: FreeRTOS_demo.c FreeRTOS_demo.h
  group user
    ./user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h isr.c isr.h
  group tools
    ./tools/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c seekfree_assistant_interface.h onenet.c onenet.h
  group freertos
    ./freertos/: croutine.c event_groups.c list.c queue.c tasks.c
    ./freertos/portable/MemMang/: heap_4.c
    ./freertos/portable/RVDS/ARM_CM3/: port.c
